# Repository ericek111/r-decadebox

File README.md:

# r-decadebox
Resistor decade box - school project

## KiCad design odporova_dekada-3.0w.kicad_pcb

Parts:
J1, J2: Conn_01x01; Banana_Jack_1Pin
R1, R2, R3, R4, R5, R6, R7, R8, R9: 1R; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R10, R11, R12, R13, R14, R15, R16, R17, R18: 10R; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R19, R20, R21, R22, R23, R24, R25, R26, R27: 100R; R_Axial_DIN0617_L17.0mm_D6.0mm_P20.32mm_Horizontal
R28, R29, R30, R31, R32, R33, R34, R35, R36: 1K; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R37, R38, R39, R40, R41, R42, R43, R44, R45: 10K; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R46, R47, R48, R49, R50, R51, R52, R53, R54: 100K; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
R55, R56, R57, R58, R59, R60, R61, R62, R63: 1M; R_Axial_DIN0414_L11.9mm_D4.5mm_P15.24mm_Horizontal
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33, U34, U35, U36, U37, U38, U39, U40, U41, U42, U43, U44, U45, U46, U47, U48, U49, U50, U51, U52, U53, U54, U55, U56, U57, U58, U59, U60, U61, U62, U63, U64, U65, U66, U67, U68, U69, U70: P-SRS22F-SPDT

Connections:
unnamed: J1.1, U61.2, U62.2, U63.2, U64.2, U65.2, U66.2, U67.2, U68.2, U69.2, U70.2
unnamed: J2.1, R1.2, U1.1
unnamed: R1.1, R2.2, U2.1
unnamed: R2.1, R3.2, U3.1
unnamed: R3.1, R4.2, U4.1
unnamed: R4.1, R5.2, U5.1
unnamed: R5.1, R6.2, U6.1
unnamed: R6.1, R7.2, U7.1
unnamed: R7.1, R8.2, U8.1
unnamed: R8.1, R9.2, U9.1
unnamed: R9.1, U10.1
unnamed: R10.1, R11.2, U12.1
unnamed: R10.2, U1.2, U2.2, U3.2, U4.2, U5.2, U6.2, U7.2, U8.2, U9.2, U10.2, U11.1
unnamed: R11.1, R12.2, U13.1
unnamed: R12.1, R13.2, U14.1
unnamed: R13.1, R14.2, U15.1
unnamed: R14.1, R15.2, U16.1
unnamed: R15.1, R16.2, U17.1
unnamed: R16.1, R17.2, U18.1
unnamed: R17.1, R18.2, U19.1
unnamed: R18.1, U20.1
unnamed: R19.1, R20.2, U22.1
unnamed: R19.2, U11.2, U12.2, U13.2, U14.2, U15.2, U16.2, U17.2, U18.2, U19.2, U20.2, U21.1
unnamed: R20.1, R21.2, U23.1
unnamed: R21.1, R22.2, U24.1
unnamed: R22.1, R23.2, U25.1
unnamed: R23.1, R24.2, U26.1
unnamed: R24.1, R25.2, U27.1
unnamed: R25.1, R26.2, U28.1
unnamed: R26.1, R27.2, U29.1
unnamed: R27.1, U30.1
unnamed: R28.1, R29.2, U32.1
unnamed: R28.2, U21.2, U22.2, U23.2, U24.2, U25.2, U26.2, U27.2, U28.2, U29.2, U30.2, U31.1
unnamed: R29.1, R30.2, U33.1
unnamed: R30.1, R31.2, U34.1
unnamed: R31.1, R32.2, U35.1
unnamed: R32.1, R33.2, U36.1
unnamed: R33.1, R34.2, U37.1
unnamed: R34.1, R35.2, U38.1
unnamed: R35.1, R36.2, U39.1
unnamed: R36.1, U40.1
unnamed: R37.1, R38.2, U42.1
unnamed: R37.2, U31.2, U32.2, U33.2, U34.2, U35.2, U36.2, U37.2, U38.2, U39.2, U40.2, U41.1
unnamed: R38.1, R39.2, U43.1
unnamed: R39.1, R40.2, U44.1
unnamed: R40.1, R41.2, U45.1
unnamed: R41.1, R42.2, U46.1
unnamed: R42.1, R43.2, U47.1
unnamed: R43.1, R44.2, U48.1
unnamed: R44.1, R45.2, U49.1
unnamed: R45.1, U50.1
unnamed: R46.1, R47.2, U52.1
unnamed: R46.2, U41.2, U42.2, U43.2, U44.2, U45.2, U46.2, U47.2, U48.2, U49.2, U50.2, U51.1
unnamed: R47.1, R48.2, U53.1
unnamed: R48.1, R49.2, U54.1
unnamed: R49.1, R50.2, U55.1
unnamed: R50.1, R51.2, U56.1
unnamed: R51.1, R52.2, U57.1
unnamed: R52.1, R53.2, U58.1
unnamed: R53.1, R54.2, U59.1
unnamed: R54.1, U60.1
unnamed: R55.1, R56.2, U62.1
unnamed: R55.2, U51.2, U52.2, U53.2, U54.2, U55.2, U56.2, U57.2, U58.2, U59.2, U60.2, U61.1
unnamed: R56.1, R57.2, U63.1
unnamed: R57.1, R58.2, U64.1
unnamed: R58.1, R59.2, U65.1
unnamed: R59.1, R60.2, U66.1
unnamed: R60.1, R61.2, U67.1
unnamed: R61.1, R62.2, U68.1
unnamed: R62.1, R63.2, U69.1
unnamed: R63.1, U70.1

Board: 2 copper layers, 196.8 x 195.6 mm, 135 parts (0 on the bottom side), 71 nets.

## Commit log

2018-01-18 First commit.
2018-03-01 Widened tracks
2018-05-03 Widened tracks to 3mm.
